# Keil uVision project hello-world.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello-world +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: LED.c main.c SysClock.c system_stm32f3xx.c SysTick.c LED.h Macros.h startup_stm32f303xe.s stm32f303xe.h SysClock.h SysTick.h DC_Motor.c Encoder.c LCD.c RC_Servo.c Stepper_Motor.c DC_Motor.h Encoder.h LCD.h RC_Servo.h Stepper_Motor.h UART.c UART.h Robot_Command.c Control_Law.c DAC.c DAC.h Control_Law.h
software components: CMSIS:CORE 5.3.0
